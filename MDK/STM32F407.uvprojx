# Keil uVision project STM32F407.uvprojx, settings and files
target STM32F407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bin --output="$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,APP_BUILD
  c include: ..\User\Application\Inc;..\User\Task\Inc;..\User\UI\Inc;..\User\Resource\Inc;..\BSP\Inc;..\Core;..\Core\Startup;..\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_StdPeriph_Driver\src;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable;..\Middlewares\LittleFS\Inc;..\Middlewares\Lvgl;..\Middlewares\Lvgl\lvgl;..\Middlewares\Lvgl\lvgl\src;..\Middlewares\Lvgl\porting;..\Boot\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER/Config
    ../User/Application/Inc/: BuildConfig.h stm32f4xx_conf.h
    ../Middlewares/FreeRTOS/portable/: FreeRTOSConfig.h
    ../User/Task/Inc/: Task_Config.h
    ../Middlewares/LittleFS/Inc/: lfs_config.h
    ../Middlewares/Lvgl/: lv_conf.h
  group USER/Application
    ../User/Application/Src/: main.c Board.c App.c app_task.c bare_test.c Provision.c stm32f4xx_it.c OTA.c
  group USER/UI
    ../User/UI/Src/: Boot_Page.c Main_Page.c UI_Mode.c UI_Day.c UI_Night.c UI_Input.c ui.c ui_events.c ui_helpers.c
    ../User/UI/Src/screens/: ui_WiFi.c ui_location.c
  group USER/Task
    ../User/Task/Src/: DHT22_Task.c Key_Task.c LightSensor_Task.c Net_Task.c Task_Common.c Task_Monitor.c UI_Task.c OTA_Task.c
  group UAER/RESOURCE
    ../User/Resource/Src/Font/: Chinese_Font16.c Chinese_Font22.c Font_12.c Font_16.c Font_22.c Font_32.c Font_48.c
    ../User/Resource/Src/Image/: Image.c Image_Boot_Page.c Image_Main_Page.c Image_Weather.c ImageTable.c
  group BSP
    ../BSP/Src/: Asset.c AT.c DHT22.c External_RTC.c I2C.c Key.c LCD.c Light_Sensor.c OLED.c Profiling.c Timer.c Touch.c Usart.c W25Q64.c OTA_Store.c OTA_Serial.c
  group STARTUP
    ../Core/Startup/: startup_stm32f40xx.s
  group CMSIS
    ../Core/: stm32f4xx.h system_stm32f4xx.h system_stm32f4xx.c core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/: heap_4.c port.c
  group Middlewares/LittleFS
    ../Middlewares/LittleFS/Src/: lfs.c lfs_operation.c lfs_port.c lfs_util.c
  group Middlewares/Lvgl/lvgl
    ../Middlewares/Lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/Lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c lv_draw_layer.c lv_draw_transform.c
    ../Middlewares/Lvgl/lvgl/src/extra/: lv_extra.c
    ../Middlewares/Lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/Lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/Lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/Lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Middlewares/Lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/Lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/Lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/Lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/Lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/Lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/Lvgl/lvgl/src/extra/widgets/win/: lv_win.c
  group Middlewares/Lvgl/porting
    ../Middlewares/Lvgl/porting/: lv_port_disp.c lv_port_indev.c lv_port_fs.c
  group BOOT
    ../Boot/Src/: boot_param.c boot_crc32.c
