# Keil uVision project STM32F407_Boot.uvprojx, settings and files
target STM32F407_Boot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_Boot
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bin --output="$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,BOOT_BUILD,LFS_READONLY
  c misc: --diag_suppress=177
  c include: ..\Boot\Inc;..\Core;..\Core\Startup;..\STM32F4xx_StdPeriph_Driver\inc;..\User\Application\Inc;..\BSP\Inc;..\Middlewares\LittleFS\Inc
  asm misc: --diag_suppress=177
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group BOOT
    ../Boot/Src/: boot_main.c boot_param.c boot_crc32.c boot_uart.c boot_lfs.c boot_update.c
  group STARTUP
    ../Core/Startup/: startup_stm32f40xx.s
  group CMSIS
    ../Core/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_spi.c
  group CONFIG
    ../User/Application/Inc/: stm32f4xx_conf.h
  group LittleFS
    ../Middlewares/LittleFS/Src/: lfs.c lfs_util.c
  group BSP
    ../BSP/Src/: W25Q64.c
